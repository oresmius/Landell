options:
  parameters:
    generate_options: qt_gui
    id: Landell_sigma_delta
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.02'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1205'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/fabio/Compartilhada/erro.dat
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/fabio/Downloads/34210__acclivity__i-am-female.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """
          1st-order sigma-delta modulator (1-bit)
          """
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name='sdm1',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
              )
              self.acc = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]

              for n in range(len(x)):
                  bit = 1.0 if self.acc >= 0.0 else 0.0
                  self.acc += float(x[n]) - bit
                  y[n] = bit

              return len(y)
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '300'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '3000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '8192'
    srate: samp_rate
    type: float
    ymax: '0.2'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '8192'
    srate: samp_rate
    type: float
    ymax: '0.2'
    ymin: '0'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '147'
    fbw: '0.4'
    interp: '1000'
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_max_xx_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_max_xx_0, '1']
- [blocks_delay_0, '0', blocks_sub_xx_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_max_xx_0, '0', blocks_delay_0, '0']
- [blocks_max_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_max_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_max_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_sub_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', low_pass_filter_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_mag_0, '0']
- [hilbert_fc_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0, '0', blocks_sub_xx_0, '1']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [low_pass_filter_1, '0', hilbert_fc_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
